# Keil uVision project CH32F20x_NFC_PCD.uvprojx, settings and files
target CH32F20x_NFC_PCD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CH32F203C8 WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F20x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Core\CMSIS;.\Drivers\StdPeriphDriver\inc;.\Drivers\Debug;.\Drivers\NFC_Reader;.\Src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Core
    ./Core/CMSIS/: core_cm3.c
    ./Core/Startup/: startup_ch32f20x_D8.s
  group StdPeriphDriver
    ./Drivers/StdPeriphDriver/src/: ch32f20x_adc.c ch32f20x_bkp.c ch32f20x_can.c ch32f20x_crc.c ch32f20x_dac.c ch32f20x_dbgmcu.c ch32f20x_dma.c ch32f20x_dvp.c ch32f20x_eth.c ch32f20x_exti.c ch32f20x_flash.c ch32f20x_fsmc.c ch32f20x_gpio.c ch32f20x_i2c.c ch32f20x_iwdg.c ch32f20x_misc.c ch32f20x_opa.c ch32f20x_pwr.c ch32f20x_rcc.c ch32f20x_rng.c ch32f20x_rtc.c ch32f20x_sdio.c ch32f20x_spi.c ch32f20x_tim.c ch32f20x_usart.c ch32f20x_wwdg.c
  group NFC_Reader
    ./Drivers/NFC_Reader/: NFC_Reader.c NFC_Reader.h NFC_Reader_bsp.c NFC_Reader_bsp.h NFC_Reader_M1.c NFC_Reader_M1.h wch_nfc_pcd.h wch_nfc_pcd.lib
  group Debug
    ./Drivers/Debug/: debug.c debug.h
    ./Drivers/Debug/printf/: printf.c printf.h printf_config.h
  group User
    ./Src/: ch32f20x_conf.h ch32f20x_it.c ch32f20x_it.h Main.c system_ch32f20x.c system_ch32f20x.h
